# Keil uVision project ch.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ch
  c flags: Optim=4 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c misc: --c99 -USTM32F40_41xxx
  c include: ..\;..\..\..\..\..\os\common\ports\ARMCMx\devices\STM32F4xx;..\..\..\..\..\os\ext\CMSIS\include;..\..\..\..\..\os\ext\CMSIS\ST;..\..\..\..\..\os\rt\ports\ARMCMx;..\..\..\..\..\os\rt\ports\ARMCMx\compilers\RVCT;..\..\..\..\..\os\rt\include;..\..\..\..\..\os\hal\osal\rt;..\..\..\..\..\os\hal\include;..\..\..\..\..\os\hal\boards\ST_STM32F4_DISCOVERY;..\..\..\..\..\os\hal\lib\streams;..\..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\..\os\hal\ports\STM32\STM32F4xx;..\..\..\..\..\os\hal\ports\STM32\LLD;..\..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\..\os\hal\ports\STM32\LLD\USARTv1;..\..\..\..\..\testhal\common;..\..\..\..\..\lwip_v1.3.2\src\include\lwip;..\..\..\..\..\lwip_v1.3.2\src\include;..\..\..\..\..\httpserver\inc;..\..\..\..\..\lwip_v1.3.2\port\STM32F4x7;..\..\..\..\..\lwip_v1.3.2\src\include\ipv4;..\..\..\..\..\os\various\lwip_bindings;..\..\..\..\..\os\various\lwip_bindings
  asm misc: --cpreproc
  asm include: ..\;..\..\..\..\..\os\common\ports\ARMCMx\devices\STM32F4xx;..\..\..\..\..\os\rt\ports\ARMCMx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x1
  group board
    ../../../../../os/hal/boards/ST_STM32F4_DISCOVERY/: board.c
  group port
    ../../../../../os/common/ports/ARMCMx/compilers/RVCT/: vectors.s cstartup.s
    ../../../../../os/rt/ports/ARMCMx/: chcore.c chcore_v7m.c
    ../../../../../os/rt/ports/ARMCMx/compilers/RVCT/: chcoreasm_v7m.s
  group kernel
    ../../../../../os/rt/src/: chvt.c chcond.c chdebug.c chdynamic.c chevents.c chheap.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c
  group hal
    ../../../../../os/hal/src/: serial.c gpt.c hal.c st.c
  group platform
    ../../../../../os/hal/ports/STM32/STM32F4xx/: hal_lld.c
    ../../../../../os/hal/ports/STM32/LLD/GPIOv2/: pal_lld.c
    ../../../../../os/hal/ports/STM32/LLD/TIMv1/: gpt_lld.c st_lld.c
    ../../../../../os/hal/ports/STM32/LLD/USARTv1/: serial_lld.c
    ../../../../../os/hal/ports/common/ARMCMx/: nvic.c
  group demo
    ../: mcuconf.h chconf.h halconf.h
    ../../../../common/: irq_storm.c
    ../../../../../os/hal/lib/streams/: chprintf.c memstreams.c
    ../../../../../mqtt/: main.c
  group mqtt_bards
    ../../../../../mqtt/boards/NONSTANDARD_STM32F4_DISCOVERY_DP83848/: board.c
  group mqtt
    ../../../../../mqtt/mqtt/: mqtt.c MQTTClient.c MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTlwip.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group web
    ../../../../../mqtt/web/: web.c
  group lwip
    ../../../../../lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group test
    ../../../../../test/rt/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testsys.c testthd.c
